# Keil uVision project bms_bringup.uvprojx, settings and files
target bms_bringup (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bms_bringup +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../App/Inc;../Bsp/Inc;../Devices/Inc;../Components/Bms/Inc;../Components/Sensing/Inc;../Components/Protocol/Inc
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Inc/: main.h stm32f1xx_hal_conf.h stm32f1xx_it.h adc.h gpio.h usart.h can.h
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c i2c.c iwdg.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Application/App
    ../App/Src/: bms_comm.c bms_config.c bms_ipc.c bms_sampling.c bms_tasks.c
    ../App/Inc/: bms_app_types.h bms_comm.h bms_config.h bms_ipc.h bms_sampling.h bms_tasks.h
  group Application/Bsp
    ../Bsp/Src/: bsp_analog.c bsp_output.c bsp_transport.c bsp_watchdog.c
    ../Bsp/Inc/: bsp_analog.h bsp_output.h bsp_transport.h bsp_watchdog.h
  group Application/Devices
    ../Devices/Src/: ina226.c
    ../Devices/Inc/: ina226.h
  group Components/Bms
    ../Components/Bms/Src/: bms_controller.c bms_protection.c bms_recovery.c bms_state_machine.c bms_energy.c bms_health.c bms_watchdog.c
    ../Components/Bms/Inc/: bms_controller.h bms_protection.h bms_recovery.h bms_state_machine.h bms_status.h bms_types.h bms_energy.h bms_health.h bms_watchdog.h
  group Components/Sensing
    ../Components/Sensing/Src/: ntc.c sample_filter.c
    ../Components/Sensing/Inc/: ntc.h sample_filter.h
  group Components/Protocol
    ../Components/Protocol/Src/: bms_protocol.c
    ../Components/Protocol/Inc/: bms_protocol.h
software components: CMSIS:CORE 4.3.0
